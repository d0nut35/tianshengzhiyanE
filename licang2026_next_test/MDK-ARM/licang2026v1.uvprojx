# Keil uVision project licang2026v1.uvprojx, settings and files
target licang2026v1 (6220000::V6.22::ARMCLANG)
  device: STM32F750V8Tx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: licang2026v1 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F750xx,RTT_USE_ASM=0,LICANG_RELEASE_MINIMAL=1
  c include: ../Core/Inc;../01_App/lsc16_device;../02_Service/lsc16;../03_Middleware/lsc16;../04_Bsp/lsc16;../05_Test/lsc16;../01_App/mult_uart_device;../02_Service/mult_uart;../03_Middleware/mult_uart;../03_Middleware/nano_vision;../03_Middleware/ball_manifest;../04_Bsp/mult_uart;../04_Bsp/uart_dispatch;../01_App/ic_card_device;../02_Service/ic_card;../03_Middleware/ic_card;../04_Bsp/ic_card;../01_App/zdt_turntable_device;../02_Service/zdt_turntable;../03_Middleware/zdt_turntable;../04_Bsp/zdt_turntable;../04_Bsp/photo_gate;../05_Test/zdt_turntable;../05_Test/common;../05_Test;../05_Test/mult_uart;../05_Test/mult_uart_modules;../05_Test/turntable_grasp_lite;../05_Test/ic_card;../02_Service/chassis_bridge;../lhy/01_App;../lhy/02_Service;../lhy/03_Middleware;../lhy/03_Middleware/chassis;../lhy/03_Middleware/map;../lhy/03_Middleware/pid;../lhy/04_Bsp;../lhy/04_Bsp/zdt_motor;../lhy/04_Bsp/hwt101;../lhy/04_Bsp/ble;../lhy/99_Utils;../lhy/99_Utils/rtt;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group 01_App/mult_uart_device
    ../01_App/mult_uart_device/: mult_uart_device.c mult_uart_device.h
  group 02_Service/mult_uart
    ../02_Service/mult_uart/: mult_uart_service.c mult_uart_service.h mult_uart_service_os.c mult_uart_service_os.h
  group 03_Middleware/mult_uart
    ../03_Middleware/mult_uart/: mult_uart_core.c mult_uart_core.h
  group 04_Bsp/mult_uart
    ../04_Bsp/mult_uart/: mult_uart_stm32_hal.c mult_uart_stm32_hal.h mult_uart_board_config.h
  group 03_Middleware/nano_vision
    ../03_Middleware/nano_vision/: nano_vision_core.c nano_vision_core.h
  group 03_Middleware/ball_manifest
    ../03_Middleware/ball_manifest/: ball_manifest_core.c ball_manifest_core.h
  group 04_Bsp/uart_dispatch
    ../04_Bsp/uart_dispatch/: uart_dispatch.c uart_dispatch.h
  group 05_Test/mult_uart
    ../05_Test/: test_config.h
    ../05_Test/mult_uart/: mult_uart_test_protocol.c mult_uart_test_protocol.h mult_uart_baremetal_test.c mult_uart_baremetal_test.h mult_uart_freertos_test.c mult_uart_freertos_test.h
  group 01_App/lsc16_device
    ../01_App/lsc16_device/: lsc16_device.c lsc16_device.h
  group 02_Service/lsc16
    ../02_Service/lsc16/: lsc16_service.c lsc16_service.h lsc16_service_os.c lsc16_service_os.h
  group 03_Middleware/lsc16
    ../03_Middleware/lsc16/: lsc16_core.c lsc16_core.h
  group 04_Bsp/lsc16
    ../04_Bsp/lsc16/: lsc16_stm32_hal.c lsc16_stm32_hal.h
  group 05_Test/lsc16
    ../05_Test/lsc16/: lsc16_test_config.h lsc16_test_common.c lsc16_test_common.h lsc16_baremetal_test.c lsc16_baremetal_test.h lsc16_freertos_test.c lsc16_freertos_test.h
  group 01_App/ic_card_device
    ../01_App/ic_card_device/: ic_card_device.c ic_card_device.h ic_card_device_config.h ic_ball_rule_2026.c ic_ball_rule_2026.h
  group 02_Service/ic_card
    ../02_Service/ic_card/: ic_card_service.c ic_card_service.h ic_card_service_os.c ic_card_service_os.h
  group 03_Middleware/ic_card
    ../03_Middleware/ic_card/: ic_card_core.c ic_card_core.h
  group 04_Bsp/ic_card
    ../04_Bsp/ic_card/: ic_card_uart7_hal.c ic_card_uart7_hal.h
  group 05_Test/common
    ../05_Test/common/: debug_uart1.c debug_uart1.h
  group 05_Test/ic_card
    ../05_Test/ic_card/: ic_card_test_config.h ic_card_test_common.c ic_card_test_common.h ic_card_baremetal_test.c ic_card_baremetal_test.h ic_card_freertos_test.c ic_card_freertos_test.h
  group 01_App/zdt_turntable_device
    ../01_App/zdt_turntable_device/: zdt_turntable_device.c zdt_turntable_device.h
  group 02_Service/zdt_turntable
    ../02_Service/zdt_turntable/: zdt_turntable_service.c zdt_turntable_service.h
  group 03_Middleware/zdt_turntable
    ../03_Middleware/zdt_turntable/: zdt_turntable_core.c zdt_turntable_core.h
  group 04_Bsp/zdt_turntable
    ../04_Bsp/zdt_turntable/: zdt_turntable_uart7_hal.c zdt_turntable_uart7_hal.h
  group 05_Test/zdt_turntable
    ../05_Test/zdt_turntable/: zdt_turntable_test_config.h zdt_turntable_test_common.c zdt_turntable_test_common.h zdt_turntable_baremetal_test.c zdt_turntable_baremetal_test.h zdt_turntable_freertos_test.c zdt_turntable_freertos_test.h
  group 04_Bsp/photo_gate
    ../04_Bsp/photo_gate/: photo_gate_board_config.h photo_gate_stm32_hal.c photo_gate_stm32_hal.h
  group 05_Test/mult_uart_modules
    ../05_Test/mult_uart_modules/: mult_uart_modules_test_config.h mult_uart_modules_freertos_test.c mult_uart_modules_freertos_test.h
  group 05_Test/turntable_grasp_lite
    ../05_Test/turntable_grasp_lite/: turntable_grasp_lite_config.h turntable_grasp_lite_freertos_test.c turntable_grasp_lite_freertos_test.h
  group 02_Service/chassis_bridge
    ../02_Service/chassis_bridge/: chassis_bridge.c chassis_bridge.h chassis_mission_link.c chassis_mission_link.h
  group 01_App/mission
    ../01_App/mission/: mission_app.c mission_app.h mission_config.h
  group lhy/01_App
    ../lhy/01_App/: app_main.c app_main.h
  group lhy/02_Service
    ../lhy/02_Service/: system_assembly.c system_assembly.h chassis_service.c chassis_service.h
  group lhy/03_Middleware/chassis
    ../lhy/03_Middleware/chassis/: mecanum_chassis.c mecanum_chassis.h chassis_adaption.c chassis_adaption.h
  group lhy/03_Middleware/map
    ../lhy/03_Middleware/map/: map.c map.h map_adaption.c map_adaption.h map_cfg.h
  group lhy/03_Middleware/pid
    ../lhy/03_Middleware/pid/: pid.c pid.h pid_adaption.c pid_adaption.h
  group lhy/04_Bsp/zdt_motor
    ../lhy/04_Bsp/zdt_motor/: zdt_motor.c zdt_motor.h zdt_motor_handler.c zdt_motor_handler.h zdt_cmd.c zdt_cmd.h zdt_motor_adaption.c zdt_motor_adaption.h
  group lhy/04_Bsp/hwt101
    ../lhy/04_Bsp/hwt101/: hwt101.c hwt101.h hwt101_adaption.c hwt101_adaption.h
  group lhy/04_Bsp/ble
    ../lhy/04_Bsp/ble/: ble.c ble.h ble_adaption.c ble_adaption.h
  group lhy/04_Bsp/lsensor
    ../lhy/04_Bsp/lsensor/: lsensor_handler.c lsensor_handler.h lsensor.h lsensor_config.h
  group lhy/99_Utils/rtt
    ../lhy/99_Utils/rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT.h SEGGER_RTT_Conf.h cat_log.h
software components: CMSIS:CORE 6.2.0
